options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: record_ref
    output_language: python
    realtime_scheduling: '1'
    run_options: run
  states: {}

blocks:
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: center_freq - channel_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: file_loc+str(datetime.datetime.now()).replace(" ","_").replace(":","_").replace(".","_")
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: num_samples
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: center_freq
  id: parameter
  parameters:
    label: center_freq
    type: intx
    value: '436000000'
  states: {}
- name: channel_freq
  id: parameter
  parameters:
    label: channel_freq
    type: intx
    value: '437000000'
  states: {}
- name: file_loc
  id: parameter
  parameters:
    label: file_loc
    type: str
    value: '"/tmp/lasso_capture"'
  states: {}
- name: hackrf_index
  id: parameter
  parameters:
    label: hackrf_index
    type: intx
    value: '0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import datetime
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: num_samples
  id: parameter
  parameters:
    label: num_samples
    type: intx
    value: '10000000'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0,bias=1
    bb_gain0: '20'
    clock_source0: external
    dc_offset_mode0: '2'
    freq0: center_freq
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: pc_clock
    time_source0: external
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: channel_freq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: channel_freq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    type: intx
    value: '2000000'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_head_0, '0', blocks_file_meta_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_head_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
